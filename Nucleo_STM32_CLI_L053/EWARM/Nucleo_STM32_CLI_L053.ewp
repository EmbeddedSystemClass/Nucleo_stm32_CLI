# IAR project Nucleo_STM32_CLI_L053.ewp, settings and files
configuration Nucleo_STM32_CLI_L053 Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32L0xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Nucleo_STM32_CLI_L053 Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l053xx.s startup_stm32l053xx.s startup_stm32l053xx.s
  group Application/User
    ../Src/: freertos.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c stm32l0xx_hal_msp.c stm32l0xx_it.c main.c freertos.c stm32l0xx_hal_msp.c stm32l0xx_it.c main.c freertos.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c system_stm32l0xx.c system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_uart.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_uart.c stm32l0xx_hal_flash_ramfunc.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c timers.c queue.c tasks.c list.c croutine.c timers.c queue.c tasks.c list.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s port.c portasm.s port.c portasm.s
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
