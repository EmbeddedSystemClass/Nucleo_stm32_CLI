<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo_STM32_CLI_L053.ewp</path>
  </project>
  <batchBuild />
</workspace>
